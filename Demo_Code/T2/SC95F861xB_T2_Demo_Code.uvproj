# Keil uVision project SC95F861xB_T2_Demo_Code.uvproj, settings and files
target Target 1 (MCS-51)
  device: SC92F8447 SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF)  XRAM(0-0x6FF) CLOCK(16000000)
  output: SC95F8X1X_T2_Demo_Code +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./c/: main.c
    ./lib/: S_TouchKeyCFG.C SC95F8X1XB_HighSensitive_lib_T2_S_V2.2.0.LIB
